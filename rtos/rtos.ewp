# IAR project rtos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411RE ST STM32F411RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: CortexM0; ..\AbstractHardware\Registers\CortexM4; ..\AbstractHardware\Registers\CortexM4\FieldValues; ..\AbstractHardware\Registers\MDR1986VE4; ..\AbstractHardware\Registers\MDR1986VE4\FieldValues; ..\AbstractHardware\Registers; ..\Common; C:\GitHub\CortexLib\AbstractHardware\Atomic; Source; Source\CriticalSection; Config; $PROJ_DIR$; ..\AbstractHardware\Registers; ..\AbstractHardware\Registers\STM32F411; ..\AbstractHardware\Registers\STM32F411\FieldValues; ..\AbstractHardware\Atomic
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.IccLang: 1
  group (top)
    Source/CriticalSection/: criticalsection.cpp
    CortexM0/: interrupthandlers.s
    ./: main.cpp rtos.hpp startup.cpp
    Source/: taskerschedule.cpp
