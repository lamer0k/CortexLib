<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\LedCpp\BookCpp.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\1\LedCpp\BookCpp.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\LedCpp17\BookCpp.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\iartproject.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\Git\stm32Labs\Lab4\lab4.ewp</path>
    </project>
    <project>
        <path>C:\Users\Sergey\Documents\IARProjects\Test1\test.ewp</path>
    </project>
    <batchBuild />
</workspace>
