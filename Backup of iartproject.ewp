# IAR project Backup of iartproject.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411RE ST STM32F411RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: AbstractHardware\Registers; AbstractHardware\Pin; AbstractHardware\Port; AbstractHardware\Timer; AbstractHardware\Atomic; AbstractHardware\SystemClock; AbstractHardware\Spi; AbstractHardware\InterruptHandler; AbstractHardware\EdpElink; AbstractHardware\Registers\STM32F411; AbstractHardware\Registers\STM32F411\FieldValues; Common; Common\CriticalSection; Application\Led; Application; Application\Gui\Images; Application\Gui\Fonts; Application\Gui; AbstractHardware\Registers\CortexM4\FieldValues; AbstractHardware\Registers\CortexM4; AbstractHardware\Timer; AbstractHardware\Timer\Stm32Fxx; AbstractHardware\Timer\Stm32Fxx\STM32F411; AbstractHardware\Uart; AbstractHardware\Uart\Stm32Fxx; AbstractHardware\Uart\Stm32Fxx\STM32F411; AbstractHardware\Adc; AbstractHardware\Mlx90614; AbstractHardware\Smbus; AbstractHardware\Smbus\Stm32F4xx; AbstractHardware\Smbus\Stm32F4xx\STM32F411
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  ILINK.IlinkOutputFile: iartproject.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group (top)
    Application/Images/: imagedata.cpp
    ./: main.cpp startup.cpp
